Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-05-25T06:29:03
Written by: Processor version 6.0.0.0
Made in: Xbim.IO.MemoryModel

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: VEKTER 5 Street & area lighting luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 2700K,3000K , 4000K - Die-cast aluminium housing pre-treated before powder coating ensuring high corrosion resistance - Stainless steel fasteners in grade 316 - Durable silicone rubber gasket - Clear, impact-resistant, toughened glass diffuser - Maximum wind load resistance is 140 km/h - Surge protection 10 kV; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: VK-90001-T4-8040; ModelReference: VEKTER 5 Street & area lighting luminaires; Manufacturer: LIGMAN
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 36 W; LightFixtureMountingType: PoleTop; ManufacturersSpecificInformation: LIGMAN
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: VEKTER, Street and area lighting luminaires; Housing color: Not specified
General Information - Weight: 7.6 kg; Case length: 31.9 cm; Case width: 26 cm; Case height: 30.4 cm; Uld creation date: 25.05.2026 04:29:03
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 36 W

# IfcFlowTerminal: VK-90001-T4-8040
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: VK-90001-T4-8040; Light output ratio: 1; Luminous flux: 4839.24 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 4839.24 lm; LightEmitterNominalPower: 36 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 609521, 475: 402322, 480: 38367, 485: 36832, 490: 382506, 495: 423255, 500: 468951, 505: 504823, 510: 541923, 515: 57673, 520: 57894, 525: 611155, 530: 613829, 535: 629598, 540: 636475, 545: 644361, 550: 654589, 555: 661682, 560: 680295, 565: 709359, 570: 720587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 8201303, 605: 827334, 610: 837494, 615: 829016, 616: 814072, 617: 810179, 618: 806287, 619: 803012, 620: 797737, 625: 764787, 630: 754964, 635: 680899, 640: 658133, 645: 604845, 650: 585125, 655: 55894, 660: 486181, 665: 454614, 670: 432297, 675: 388355, 680: 352992, 685: 328193, 690: 282697, 695: 245701, 700: 235906, 705: 199853, 710: 163229, 715: 14476, 720: 13737, 725: 124158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80
